# Keil uVision project ble_app_hrs.uvproj, settings and files
target nRF51822_S110 (ARM-ADS)
  device: nRF51822 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: battery.c led.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_dis.c ble_bas.c ble_hrs.c
    ../: ble_acc.c
  group Libraries
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c app_button.c app_gpiote.c
