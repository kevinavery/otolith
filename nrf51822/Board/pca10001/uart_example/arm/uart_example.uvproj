# Keil uVision project uart_example.uvproj, settings and files
target nrf51822_xxaa (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
  group core
    ../../../../Source/templates/: system_nrf51.c
    ../../../../Source/templates/arm/: arm_startup_nrf51.s
  group lib
    ../../../../Source/simple_uart/: simple_uart.c
    ../../../../Source/acc/: acc_driver.c
    ../../../../Source/spi_master/: spi_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include;..
  library: MicroLIB
  memory RVCT4: ROM 0x14000 size 0xc000
  memory RVCT9: RAM 0x20002000 size 0x2000
