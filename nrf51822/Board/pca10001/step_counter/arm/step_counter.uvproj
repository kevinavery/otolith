# Keil uVision project step_counter.uvproj, settings and files
target nRF51822_S110 (ARM-ADS)
  device: nRF51822 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\Include;..\..\..\..\Include\app_common
  memory RVCT4: ROM 0x14000 size 0x2c000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: acc_driver.c step_counter.c
  group Libraries
    ../../../../Source/spi_master/: spi_master.c
    ../../../../Source/simple_uart/: simple_uart.c
